Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: KBE144.00 SIMPLE.ifc
Time: 2023-08-08T14:57:03
Author: Oskar
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (11)
Name
2 x  | IfcPropertySet - ObjectType: SketchupComponentInstance
 | 3DGeom-468_Defintion - Description: 3DGeom-468; ObjectType: SketchupComponentInstance
2 x  | Group - ObjectType: SketchupGroup
 | Body_1 - ObjectType: SketchupGroup
 | 3DGeom-641_Defintion - Description: 3DGeom-641; ObjectType: SketchupComponentInstance
 | 3DGeom-656_Defintion - Description: 3DGeom-656; ObjectType: SketchupComponentInstance
3 x  | 3DGeom-481_Defintion - Description: 3DGeom-481; ObjectType: SketchupComponentInstance
